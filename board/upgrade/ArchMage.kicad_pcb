# Repository MalphasWats/Mage

File README.md:

# Mage

Mage is my handheld ATTiny85 gaming project.

I've had this project bouncing around in my head for probably about 3 years now. 
Initially, I wasn't sure I could get an ATTiny85 to drive an OLED, but then a little
while ago I worked out how I could use a set of 8x8 tiles and an index map to keep
the SRAM requirements down.

After some furious breadboarding I produced a simple prototype which I transferred to protoboard

This turned out to be an immensely frustrating exercise. I *thought* I would be happy with
a simple little protoboard device that I could make a little case for with acrylic or my 3D
printer. I was wrong - this thing only worked for about 30 seconds at a time before one
connection or other wobbled and broke. The screen was really flaky and I nearly got put off
entirely.

Enter KiCAD - I vaguely remembered a [Hackaday series on making a PCB in everything](https://hackaday.com/2016/11/17/creating-a-pcb-in-everything-kicad-part-1/).
I downloaded KiCAD and promptly wept for a few days. The learning curve on creating a PCB, not just from
scratch, but with absolutely no idea how to even use the software was **steep**. But after a few days, I
took another stab and came up with something not half bad. In the end, one of the hardest parts was getting
a board outline imported from a vector app - I used a photo of a GameBoy Advance and drew around it!

I sent the files off to OSH Park and waited. 

I was so very pleased with what I'd created, I immediately set off to create a demo game - that's the
game contained in this repository. My ambitions grew a little faster than my knowledge of C and I've
almost squeezed as much as possible out of the ATTiny85, which is quite satisfying.

The board itself wasn't quite what I had imagined way back when I first had the idea - I'd seen things like
the Gamebuino, which are really neat (and small). So I fired up KiCAD again and had another crack.

The second revision was much smaller - I used OpenSCAD to design the outline (3 octagons and a rectangle), 
which imported straight into KiCAD without any issue. The whole thing is smaller and I decided to use a
CR2032 cell to power it, instead of the 3.7v Lipo & charger that I originally put on the board.

There were a few small issues, my first effort at soldering one nuked some of the traces and it took me a
while to realise what had caused the problems. I also discovered that the springiness of the battery clip
was too much for the small solder pads I'd defined and the battery clip pinged off taking the copper pad
with it!

I'm not entirely sure why it still works, but after a bit of hot glue action, the board was working again!
I wasn't happy with the layout - the screen overlapped awkwardly and the CR2023 was nice, but didn't actually
make it any thinner or smaller than a Lipo, so I returned to the drawing board and produced a *Final Version*
for which I am currently awaiting delivery.

## KiCad design board/upgrade/ArchMage.kicad_pcb

Schematic: ArchMage.sch

Parts:
J1: ISP; Pin_Header_Straight_2x03_Pitch2.54mm
J2: DIP8; DIP-8_W7.62mm
U1: ATmega1284P-AU; TQFP-44_10x10mm_Pitch0.8mm

Connections:
AD2: J2.3, U1.35 (PA2)
GND: J1.6, J2.4, U1.6 (GND), U1.18 (GND), U1.28 (GND), U1.39 (GND)
MISO: J1.1, U1.2 (PB6)
MOSI: J1.4, U1.1 (PB5)
PB0: J2.5, U1.40 (PB0)
PB1: J2.6, U1.41 (PB1)
PB2: J2.7, U1.42 (PB2)
PB3: J2.2, U1.43 (PB3)
RESET: J1.5, J2.1, U1.4 (~RESET)
SCK: J1.3, U1.3 (PB7)
Vcc: J1.2, J2.8, U1.5 (VCC), U1.17 (VCC), U1.27 (AVCC), U1.38 (VCC)

Board: 2 copper layers, 15.5 x 21.0 mm, 3 parts (0 on the bottom side), 11 nets, no tracks yet.

## KiCad design board/Mage.kicad_pcb

Parts:
BT1: 3.7v Lipo; LiPo_Pads
C0: 1.0uF; C_Rect_L7.0mm_W2.5mm_P5.00mm
C1, C2: 0.1uF; C_Rect_L7.0mm_W2.5mm_P5.00mm
D0: D_ALT; D_A-405_P7.62mm_Horizontal
LS1: Speaker; Generic_Speaker
R1: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 68k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6: 220k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7: 300k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW0: Reset; SW_PUSH_6mm_h5mm
SW1: Up; SW_PUSH_6mm_h5mm
SW2: Down; SW_PUSH_6mm_h5mm
SW3: Left; SW_PUSH_6mm_h5mm
SW4: Right; SW_PUSH_6mm_h5mm
SW5: A; SW_PUSH_6mm_h5mm
SW6: B; SW_PUSH_6mm_h5mm
SW7: C; SW_PUSH_6mm_h5mm
SW8: POWER; SW_DIP_x1_W7.62mm_Slide
U1: ATTiny85; TQFP-44_10x10mm_Pitch0.8mm
U2: SSD1306_OLED; Wafer_Vertical20x5.8x7RM2.5-7

Connections:
+3V3: C1.2, C2.2, D0.1 (K), R10.1, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.2, U1.8 (Vcc), U2.2 (VCC)
GND: BT1.2, C0.2, C1.1, C2.1, LS1.2, R9.1, SW0.1, U1.4 (GND), U2.1 (GND), U2.7 (CS)
unnamed: BT1.1, SW8.1
unnamed: C0.1, D0.2 (A), R10.2, SW0.2, U1.1 (RST_ADC0), U2.5 (RESET)
unnamed: LS1.1, U1.5 (PB0)
unnamed: R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R9.2, U1.3 (PB4_ADC2)
unnamed: R1.2, SW1.2
unnamed: R2.2, SW2.2
unnamed: R3.2, SW3.2
unnamed: R4.2, SW4.2
unnamed: R5.2, SW5.2
unnamed: R6.2, SW6.2
unnamed: R7.2, SW7.2
unnamed: U1.2 (PB3_ADC3), U2.6 (D/C)
unnamed: U1.6 (PB1), U2.3 (CLK)
unnamed: U1.7 (PB2_ADC1), U2.4 (MOSI)

Board: 2 copper layers, 77.0 x 37.0 mm, 26 parts (2 on the bottom side), 16 nets.

## Commit log

2018-05-15 PCB Files
2018-05-15 referencey bits
2018-05-15 Map & Glyph data
2018-05-15 Initial Code Import
2018-05-15 house internal map
2018-05-15 Added house map
2018-05-15 testing push
2018-05-15 remove delta
2018-05-15 add beep.o to makefile
2018-05-15 git ignore build files
2018-05-16 big refactor
    split OLED stuff out into its own file and added support for different locations (and shoved it all in one commit because I'm a terrible person)
2018-05-16 can't display less than full screen yet
2018-05-16 *marge grumble*
2018-05-16 portals between maps properly implemented
2018-05-16 tweaked AVRDUDE options
2018-05-17 tidied a bit
2018-05-17 rotated reset diode
2018-05-17 fixed connections
2018-05-17 can't support smaller than screen maps yet
2018-05-17 basic cellar map
2018-05-17 battle screen initial concept
2018-05-18 moved point type into utils
2018-05-18 implemented player as mob_type, tidied code
2018-05-18 initial combat structure
2018-05-19 tweak device for avrdude
2018-05-20 millis() only returns an int
2018-05-20 rework OLED driver to support SH1106 controller.
2018-05-20 return to correct position when changing location
2018-05-21 symbols for battle screen (initial concept)
2018-05-21 battle screen framework functionality
2018-05-21 forgot multiplier!
2018-05-21 attack bracket misaligned
2018-05-21 health misaligned
2018-05-21 first try at scaling glyph x2
2018-05-21 didn't work
2018-05-21 procrastinating
2018-05-21 better heart glyphs
2018-05-21 nearest neighbour rescale (still not working)
2018-05-21 tactics
2018-05-22 beware the RNG
2018-05-22 added flags to makefile
2018-05-22 shhhhh
2018-05-22 shaving off a few bytes
2018-05-22 timming fat
2018-05-22 PUT SOME BACK, QUICK!
2018-05-22 oops
2018-05-23 added optimisation options
2018-05-23 added a note for later
2018-05-23 further battle_mode development
2018-05-23 select actions
2018-05-24 battlemode!
    done, but not complete - you can kill mobs and they can kill you but you get nothing for it!
2018-05-25 updated some bits
2018-05-27 tweaked button values
2018-05-27 keep trying :(
2018-05-27 display simple window
2018-06-01 Made starting village smaller
2018-06-01 fix portal location
2018-06-01 moved mob back into map bounds
2018-06-01 I don't know how to commit
2018-06-01 added (expensive) string display
2018-06-01 added container functionality
    Containers can now be created & filled and things taken from them (but
    there is currently no player inventory!)
2018-06-02 finally got block scaling working for battle mode
    also refactored things a bit to save a bit of space
2018-06-07 New, smaller PCB
2018-06-07 beginning to rework mobs & items
2018-06-07 Gnomes not Dwarves
2018-06-14 implement player inventory
2018-06-14 deprecate D button
2018-06-14 remove strings, just use glyphs
2018-06-14 make cursor position persistent between item windows
2018-06-14 embarrassing type bug
2018-06-14 keep displaying inventory until cancelled
2018-06-14 type typo
2018-06-14 i have lost the ability to count
2018-06-15 missing button timer caused single press to register as multiple
2018-06-15 combat_actions moved global
2018-06-15 tweaked death timings
2018-06-15 container size tweak
2018-06-15 tweaked wrong thing
2018-06-15 death window size
2018-06-15 don't need a window here
2018-06-15 update health on death
2018-06-15 whoops
2018-06-15 got it
2018-06-16 apples eatable for health
2018-06-17 loot from mobs, reworked glyphs to make space
2018-06-17 remove chest from maps
    Containers are separate
2018-06-22 new prototype uses SSD1306
2018-06-22 respawn after death, mobs respawn, fix bug with combat
2018-06-25 reworked board to make it neater
    Added decoupling capacitor for OLED
    Removed CR2032, replaced with Lipo
    Tweaked layout
2018-06-26 Wrote some stuff
2018-06-26 pictures
2018-06-26 url typo
2018-06-27 filename typo
2018-07-11 initial thoughts
2018-09-25 updated board to KiCAD 5.0
2018-10-09 ArchMage initial prototype
2018-10-11 Scroll added
    Scroll adds an ISP header as a plug-in extension for the ATtiny85 because I get fed up with plugging and un-plugging (and de-bending the pins) when I'm developing
2018-10-11 schematic annotations
2018-11-14 changes that I've forgotten now
